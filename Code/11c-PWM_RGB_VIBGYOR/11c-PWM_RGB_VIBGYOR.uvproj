# Keil uVision project 11c-PWM_RGB_VIBGYOR.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 11c-PWM_RGB_VIBGYOR
  AfterMake: fromelf --bin Objects\11c-PWM_RGB_VIBGYOR.axf --output 11c-PWM_RGB_VIBGYOR.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: startup_LPC17xx.s main.c
    ../00-libfiles/: gpio.c pwm.c system_LPC17xx.c uart.c
  group Header
    ../00-libfiles/: gpio.h pwm.h stdutils.h uart.h
