# Keil uVision project 06e-UART_String_RxTx_Lcd.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 06e-UART_String_RxTx_Lcd
  AfterMake: fromelf --bin 06e-UART_String_RxTx_Lcd.axf --output 06e-UART_String_RxTx_Lcd.bin
  c flags: Optim=1
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x2000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../00-libfiles/: gpio.c delay.c lcd.c uart.c
    ./: startup_LPC17xx.s main.c
  group Header
    ../00-libfiles/: delay.h lcd.h system_LPC17xx.c uart.h gpio.h
