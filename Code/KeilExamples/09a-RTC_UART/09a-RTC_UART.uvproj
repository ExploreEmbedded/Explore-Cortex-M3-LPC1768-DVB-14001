# Keil uVision project 09a-RTC_UART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 09a-RTC_UART
  AfterMake: fromelf --bin 09a-RTC_UART.axf --output 09a-RTC_UART.bin
  c flags: Optim=1
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x2000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../00-libfiles/: uart.c gpio.c rtc.c system_LPC17xx.c
    ./: startup_LPC17xx.s main.c
  group Header
    ../00-libfiles/: gpio.h rtc.h stdutils.h uart.h
