# Keil uVision project 07b-Adc_RawValue_Voltage.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 07b-Adc_RawValue_Voltage
  AfterMake: fromelf --bin 07b-Adc_RawValue_Voltage.axf --output 07b-Adc_RawValue_Voltage.bin
  c flags: Optim=1
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x2000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s main.c
    ../00-libfiles/: adc.c delay.c gpio.c system_LPC17xx.c uart.c
  group Headers file
    ../00-libfiles/: delay.h gpio.h uart.h adc.h
