# Keil uVision project ExploreLPC1768_Board_Test.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ExploreLPC1768_Board_Test +hex
  AfterMake: fromelf --bin Objects\ExploreLPC1768_Board_Test.axf --output ExploreLPC1768_Board_Test.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: startup_LPC17xx.s main.c
    ../00-libfiles/: adc.c delay.c gpio.c keypad.c lcd.c pwm.c rtc.c system_LPC17xx.c uart.c
  group Header
    ../00-libfiles/: adc.h delay.h gpio.h keypad.h lcd.h pwm.h rtc.h stdutils.h uart.h
