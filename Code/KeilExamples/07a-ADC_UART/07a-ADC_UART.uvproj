# Keil uVision project 07a-ADC_UART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 07a-ADC_UART +hex
  AfterMake: fromelf --bin 07a-ADC_UART.axf --output 07a-ADC_UART.bin
  c flags: Optim=1
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../00-libfiles/: gpio.c adc.c delay.c system_LPC17xx.c uart.c
    ./: startup_LPC17xx.s main.c
  group Header files
    ../00-libfiles/: uart.h stdutils.h gpio.h delay.h adc.h
