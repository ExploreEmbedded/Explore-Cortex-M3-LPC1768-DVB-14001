# Keil uVision project 18a-USB_VirtualCom.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 18a-USB_VirtualCom +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\00-libfiles;..\00-libfiles\usblib
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: startup_LPC17xx.s main.c
    ../00-libfiles/: system_LPC17xx.c gpio.c gpio.h delay.h delay.c
  group Header
    ../00-libfiles/: stdutils.h
  group UsbLib
    ../00-libfiles/usblib/: usbcore.c usbdesc.c usbhw.c usbserial.c cdcuser.c cdc.h cdcuser.h usb.h usbcfg.h usbcore.h usbdesc.h usbhw.h usbreg.h usbserial.h usbuser.h usbuser.c serial.c serial.h type.h
