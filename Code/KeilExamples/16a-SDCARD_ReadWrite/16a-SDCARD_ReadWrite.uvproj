# Keil uVision project 16a-SDCARD_ReadWrite.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 16a-SDCARD_ReadWrite +hex
  AfterMake: fromelf --bin 16a-SDCARD_ReadWrite.axf --output  16a-SDCARD_ReadWrite.bin
  c flags: Optim=1
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: startup_LPC17xx.s main.c
    ../00-libfiles/: delay.c fat32.c gpio.c sdcard.c spi.c system_LPC17xx.c uart.c
  group Header
    ../00-libfiles/: delay.h fat32.h gpio.h sdcard.h spi.h stdutils.h uart.h
