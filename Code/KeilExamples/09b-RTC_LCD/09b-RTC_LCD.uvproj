# Keil uVision project 09b-RTC_LCD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 09b-RTC_LCD
  AfterMake: fromelf --bin 09b-RTC_LCD.axf --output 09b-RTC_LCD.bin
  c flags: Optim=1
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x2000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s main.c
    ../00-libfiles/: delay.c gpio.c lcd.c rtc.c system_LPC17xx.c
  group Header files
    ../00-libfiles/: rtc.h lcd.h gpio.h delay.h
