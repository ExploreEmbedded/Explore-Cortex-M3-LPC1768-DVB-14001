# Keil uVision project 11a-PWM_Led_Fade.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 11a-PWM_Led_Fade
  AfterMake: fromelf --bin Objects\11a-PWM_Led_Fade.axf --output 11a-PWM_Led.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: startup_LPC17xx.s main.c
    ../00-libfiles/: pwm.c system_LPC17xx.c gpio.c delay.c
  group Header
    ../00-libfiles/: stdutils.h pwm.h gpio.h delay.h
