# Keil uVision project Eeprom_At24xx_Example1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Eeprom_At24xx_Example1 +hex
  c flags: Optim=1
  c include: ..\..\KeilExamples\00-libfiles
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s main.c
    ../../KeilExamples/00-libfiles/: delay.c delay.h eeprom.c eeprom.h gpio.c gpio.h softi2c.c softi2c.h uart.c uart.h system_LPC17xx.c stdutils.h
