# Keil uVision project Switch_Led.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Switch_Led +hex
  AfterMake: fromelf --bin Switch_Led.axf --output Switch_Led.bin
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: delay.c switchLed_main.c system_LPC17xx.c startup_LPC17xx.s gpio.c
  group Header
    ./: delay.h stdutils.h gpio.h
