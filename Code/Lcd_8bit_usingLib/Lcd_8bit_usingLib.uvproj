# Keil uVision project Lcd_8bit_usingLib.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Lcd_8bit_usingLib +hex
  AfterMake: fromelf --bin lcd_8bit_usinglib.axf --output  lcd_8bit_usinglib.bin
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: delay.c gpio.c lcd.c main.c system_LPC17xx.c startup_LPC17xx.s
  group Header
    ./: delay.h gpio.h lcd.h stdutils.h
